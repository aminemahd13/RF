options:
  parameters:
    author: hp
    generate_options: qt_gui
    id: rx_tx
    output_language: python
    title: rx tx
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"10101010101010101010101010101010"'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: pkt_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\hp\Desktop\RF\img processing\recv_data.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\hp\Desktop\RF\img processing\img_data.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pkt_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"00011101000011110011111010011010"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import struct

      class packet_framer(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name='Custom Packet Framer',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              
              # 1. CONSTANTS
              self.payload_size = 256  # Must match your "Stream to Tagged Stream"
              # Preamble (4 bytes 0x55) + Sync (4 bytes) + Length (4 bytes)
              # 0x1D0F3E9A
              self.header_bytes = [0x55, 0x55, 0x55, 0x55, 
                                   0x1D, 0x0F, 0x3E, 0x9A] 
              
              # We pre-calculate the length bytes since your packet size is fixed at 256
              # 256 in hex is 0x00000100
              self.len_bytes = list(struct.pack('>I', self.payload_size))
              
              self.full_header = self.header_bytes + self.len_bytes
              self.header_len = len(self.full_header)
              self.total_packet_len = self.header_len + self.payload_size

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # We need enough input to make a payload, and enough output space to write the full packet
              if len(in0) >= self.payload_size and len(out) >= self.total_packet_len:
                  
                  # 1. Write Header
                  out[:self.header_len] = self.full_header
                  
                  # 2. Write Payload (Copy 256 bytes from input)
                  out[self.header_len : self.total_packet_len] = in0[:self.payload_size]
                  
                  # 3. Tell GNU Radio what we did
                  self.consume(0, self.payload_size) # We ate 256 bytes
                  return self.total_packet_len       # We produced 268 bytes
                  
              # If we don't have enough data yet, do nothing and wait for more
              return 0
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: '4096'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: access_code
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bit_stream
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: qpsk
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: sym_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bit_stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: qpsk
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: sym_sync
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [channels_channel_model_0, '0', analog_agc_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_1, '0']
- [digital_symbol_sync_xx_0, '1', blocks_null_sink_0, '0']
- [digital_symbol_sync_xx_0, '2', blocks_null_sink_1, '0']
- [digital_symbol_sync_xx_0, '3', blocks_null_sink_2, '0']
- [epy_block_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
